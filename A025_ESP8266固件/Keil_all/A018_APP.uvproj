# Keil uVision project A018_APP.uvproj, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: A025_ESP07S_PLUS-2018-12-12 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\OBJ\A017_ESP07S_MCU_FW.bin  .\OBJ\A017_ESP07S_MCU_FW.axf
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\RTT;..\Source\HARDWARE\FAN;..\Source\HARDWARE\FLASH;..\Source\HARDWARE\HLK_M30;..\Source\HARDWARE\IAP;..\Source\HARDWARE\IapProc;..\Source\HARDWARE\KEY;..\Source\HARDWARE\LED;..\Source\HARDWARE\OLED;..\Source\HARDWARE\PWM_Data;..\Source\HARDWARE\RTC;..\Source\HARDWARE\SPI;..\Source\HARDWARE\STMFLASH;..\Source\HARDWARE\TEMPERATURE;..\Source\HARDWARE\TIMER;..\Source\func;..\Source\core_cm3;..\Source\STM32_cofig;..\Source\SYSTEM\delay;..\Source\SYSTEM\sys;..\Source\SYSTEM\usart;..\Source\STM32F10x_FWLib\src;..\Source\STM32F10x_FWLib\inc;..\Source\USER;..\Source\HARDWARE\KEY_UPDATA;..\Source\OhterCmd;..\Source\gbk_text;..\Source\SYSTEM\os_delay;..\Source\HARDWARE\ULN2003
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYSTEM
    ../Source/SYSTEM/delay/: delay.c
    ../Source/SYSTEM/sys/: sys.c
    ../Source/SYSTEM/usart/: usart.c
  group FWLib
    ../Source/STM32F10x_FWLib/src/: stm32f10x_adc.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_exti.c
  group Hardware
    ../Source/HARDWARE/LED/: led.c
    ../Source/HARDWARE/OLED/: oled.c display.c
    ../Source/HARDWARE/IapProc/: IapProc.c
    ../Source/HARDWARE/FLASH/: flash.c
    ../Source/HARDWARE/IAP/: iap.c
    ../Source/HARDWARE/SPI/: spi.c
    ../Source/HARDWARE/STMFLASH/: stmflash.c
    ../Source/HARDWARE/TIMER/: timer.c
    ../Source/HARDWARE/KEY/: adc.c key.c EC11_Key.c
    ../Source/HARDWARE/RTC/: rtc.c
    ../Source/HARDWARE/PWM_Data/: pwmData.c
    ../Source/HARDWARE/HLK_M30/: my_string.c HLK_M30.c ESP8266_07S.c
    ../Source/HARDWARE/FAN/: FAN.c
    ../Source/HARDWARE/TEMPERATURE/: temperature.c
    ../Source/HARDWARE/KEY_UPDATA/: KEY_UPDATA.c
    ../Source/HARDWARE/ULN2003/: uln2003.c
  group Func
    ../Source/func/: menu.c func.c weather.c TimerFunc.c LOGO.c
  group core_cm3
    ../Source/core_cm3/: core_cm3.c RTX_Conf_CM.c startup_stm32f10x_md.s
  group user
    ../Source/USER/: CmdProc.c main.c
  group stm32_config
    ../Source/STM32_cofig/: stm32f10x_it.c system_stm32f10x.c
  group ohtercmd
    ../Source/OhterCmd/: OtherProc.c
  group GBK_text
    ../Source/gbk_text/: gbk_text.c updataFont.c
  group SEGGER_RTT
    ../Source/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
